## config/boards/shields/well34/Kconfig.defconfig
```kconfig
if SHIELD_WELL34
            
config ZMK_KEYBOARD_NAME
    default "WELL34"

endif
```
